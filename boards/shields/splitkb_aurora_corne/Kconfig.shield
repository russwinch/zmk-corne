## boards/shields/splitkb_aurora_corne/Kconfig.shield
```kconfig
config SHIELD_AURORA_CORNE_DONGLE
    def_bool $(shields_list_contains,splitkb_aurora_corne_dongle)
```
